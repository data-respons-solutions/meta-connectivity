# Failed automatically finding zlib, we provide location:
EXTRA_OECONF += " --with-zlib=${STAGING_DIR_TARGET}/usr"
