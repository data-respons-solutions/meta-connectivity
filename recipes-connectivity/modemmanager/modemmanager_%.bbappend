RRECOMMENDS_${PN} += "modemmanager-conf"